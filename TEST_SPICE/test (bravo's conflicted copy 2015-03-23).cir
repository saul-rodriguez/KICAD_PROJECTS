**************************************************************
*  Electronic circuit simulation file generated by gSpiceUI  *
*                Version 1.0.00 (23/09/2011)                 *
**************************************************************

* EESchema Netlist Version 1.1 (Spice format) creation date: ons 15 okt 2014 21:22:32

* Component Definitions
C1 OUT 0 1u
R1 OUT IN 1000
V1 IN 0 dc 0V ac 1V

* GNU-Cap Simulation Commands
.OPTIONS NOPAGE
.PRINT OP V(OUT)
.OP 27.00 BASIC

.END
