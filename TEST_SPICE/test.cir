**************************************************************
*  Electronic circuit simulation file generated by gSpiceUI  *
*                Version 1.0.00 (23/09/2011)                 *
**************************************************************

* Component Definitions
C1 OUT 0 1u
R1 OUT IN 1000
V1 IN 0 dc 0V ac 1V

* NG-Spice Simulation Commands
.OPTIONS NOPAGE NUMDGT=6 UNITS=Degrees WIDTH=104
.PRINT DC V(IN,0) V(OUT)
.DC TEMP 0.00 100.00 10.00

.END
